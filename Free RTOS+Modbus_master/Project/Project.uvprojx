# Keil uVision project Project.uvprojx, settings and files
target 神舟IV号 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SZ_STM32F107VC_DEMO +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: .\;.\..\Libraries\CMSIS\CM3\CoreSupport;.\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Project;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\APP\inc;..\STM32_ETH_Driver\inc;..\modbus_poll;..\modbus_poll\util
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c usart.c stm32f10x_it.c led.c stm32f107.c
    ../APP/src/: sht30.c delay.c rs485.c
    ../STM32_ETH_Driver/src/: stm32_eth.c
  group StdPeriph_Driver
    ./../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ./../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK_start_code
    ./../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group FreeRTOS_CORE
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Modbus
    ../modbus_poll/: mb_poll_port_serial.c mb_poll_port_timer.c modbus_poll.c
software components: CMSIS:CORE 5.1.2
